# Keil uVision project GYROSCOPE.uvprojx, settings and files
target ARCADE (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: GYROSCOPE +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP;C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/Components;C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/STM32F429I-Discovery;C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/Components/stmpe811;C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/Components/ili9341;C:\Users\Danie\STM32Cube\Repository\STM32Cube_FW_F4_V1.28.0\Utilities\Media\Pictures\BMP_240x320
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f429xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c crc.c dma2d.c fmc.c i2c.c ltdc.c spi.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
    ./: Touchscreen.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma2d.c stm32f4xx_ll_fmc.c stm32f4xx_hal_sdram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_dsi.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32f429-Discovery
    C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c stm32f429i_discovery_eeprom.c stm32f429i_discovery_io.c stm32f429i_discovery_lcd.c stm32f429i_discovery_sdram.c stm32f429i_discovery_ts.c stm32f429i_discovery_gyroscope.c
  group Drivers/BSP/Components
    C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/Components/stmpe811/: stmpe811.c
    C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/Components/ili9341/: ili9341.c
    C:/Users/Danie/STM32Cube/Repository/STM32Cube_FW_F4_V1.28.0/Drivers/BSP/Components/l3gd20/: l3gd20.c
software components: CMSIS:CORE 6.0.0
